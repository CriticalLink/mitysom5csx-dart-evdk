SRC_URI="svn://svnsrv/svn/mityaltera/mityarm-5csx/tags/basler_vdk/sw/ARM;protocol=http;module=libfpga"

SRCREV = "${AUTOREV}"
